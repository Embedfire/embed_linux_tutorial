# IAR project Backup (2) of Fire-iMX6ULL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2CVM08
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\CORTEXA\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\user; ..\..\user\bsp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: Fire-iMX6ULL.bin
  ILINK.IlinkOutputFile: Fire-iMX6ULL.out
  ILINK.IlinkIcfFile: Fire-iMX6ULL_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Fire-iMX6ULL.srec
  group board
    ../../user/: board.c clock_config.c clock_config_ocram.c pin_mux.c
  group boot
    ../../user/boot/: ebf6ull_boot.c ebf6ull_boot.h fire_imx6ull_ddr_ini_dcd.c fire_imx6ull_ddr_ini_dcd.h
  group CMSIS
    ../../libraries/: system_MCIMX6Y2.c
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_uart.c
  group startup
    ../../libraries/iar/: startup_MCIMX6Y2.s
  group user
    ../../user/: main.c
  group utilities
    ../../libraries/utilities/: fsl_debug_console.c fsl_io.c fsl_log.c fsl_sbrk.c fsl_str.c
