<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Fire-iMX6ULL.ewp</path>
    </project>
    <batchBuild />
</workspace>
